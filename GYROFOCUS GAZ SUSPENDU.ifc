Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Pointe 8 mm; Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm; Nom de la famille: Niveau
Contraintes - Elévation: 0 mm; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 mm

# IfcBuildingElementProxy, f2788d62-4e83-4887-9123-f221e94a3527:f2788d62-4e83-4887-9123-f221e94a3527:201839
In: Niveau 1
Type - Material: Plate
Type - Autre - Catégorie: Equipement spécialisé
Type - Données d'identification - Coût: 0; Description: STEP AP214; Fabricant: Focus; Modèle: GYROFOCUS GAZ SUSPENDU; Numéro OmniClass: 23.40.20.34.14; Titre OmniClass: Fireplaces
Type - Propriétés du modèle - Aire: 9.223154e+06 millimètre^2; Auteur: Utilisateur; Centre de gravité: X: -12.154 mm Y: 539.702 mm Z: -0.009 mm; Date de création: 2020-09-17; Densité: 7.850000e-06 kilogramme/millimètre^3; Designer: fr3d; Etat de la conception: 3; Masse: 1.344211e+02 kilogramme; Matière: Acier; Part Number: GYROFOCUS GAZ SUSPENDU; Précision demandée: Faible; Revision Number: ANY; Title: GYROFOCUS GAZ SUSPENDU2.STEP; Volume: 0.0171237 m3
Pset_ManufacturerTypeInformation - Manufacturer: Focus
Autre - Famille: f2788d62-4e83-4887-9123-f221e94a3527: f2788d62-4e83-4887-9123-f221e94a3527; Famille et type: f2788d62-4e83-4887-9123-f221e94a3527: f2788d62-4e83-4887-9123-f221e94a3527; ID du type: f2788d62-4e83-4887-9123-f221e94a3527: f2788d62-4e83-4887-9123-f221e94a3527; Type: f2788d62-4e83-4887-9123-f221e94a3527: f2788d62-4e83-4887-9123-f221e94a3527
Contraintes - Décalage: 0 mm; Hôte: Aucun(e)
Cotes - Surface: 7.13803 m2; Volume: 3.48532 m3
Phase de construction - Phase de création: Nouvelle construction
